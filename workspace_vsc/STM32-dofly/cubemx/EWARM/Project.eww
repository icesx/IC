<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\xx.ewp</path>
  </project>
  <batchBuild />
</workspace>
